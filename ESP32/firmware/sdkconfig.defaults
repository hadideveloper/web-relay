## ESP32/firmware/sdkconfig.defaults
```kconfig
# Default configuration for ESP32 Hello World project
CONFIG_ESP32_DEFAULT_CPU_FREQ_240=y
CONFIG_ESP32_DEFAULT_CPU_FREQ_MHZ=240
```
